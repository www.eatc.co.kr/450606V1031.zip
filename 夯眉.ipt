# Autodesk Inventor part: 본체
## iProperties
Created: 2015-06
Part Number: 본체
Document SubType Name: Modeling
Designer: 102-
Density: 1 g/cm^3
Author: 102-
